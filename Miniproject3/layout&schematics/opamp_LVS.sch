v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/MADVLSI/Miniproject3/opamp.sym} 30 0 0 0 {name=X1}
C {devices/iopin.sym} 20 -60 3 0 {name=p1 lab=VDD}
C {devices/ipin.sym} 0 -40 1 0 {name=p2 lab=Vbp}
C {devices/ipin.sym} 40 -40 1 0 {name=p3 lab=Vcp}
C {devices/ipin.sym} 40 40 3 0 {name=p5 lab=Vcn}
C {devices/iopin.sym} 20 60 1 0 {name=p6 lab=GND}
C {devices/ipin.sym} 0 40 3 0 {name=p7 lab=Vbn}
C {devices/opin.sym} 70 0 0 0 {name=p4 lab=Vout}
C {devices/ipin.sym} -30 10 0 0 {name=p8 lab=V2}
C {devices/ipin.sym} -30 -10 0 0 {name=p9 lab=V1}
