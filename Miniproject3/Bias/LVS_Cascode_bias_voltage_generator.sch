v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/MADVLSI/Miniproject3/Bias/LDS_Cascode_bias_voltage_generator.sym} 0 0 0 0 {name=X1}
C {devices/iopin.sym} 0 -50 3 0 {name=p1 lab=VDD
}
C {devices/iopin.sym} 0 50 1 0 {name=p2 lab=GND
}
C {devices/iopin.sym} 50 -30 0 0 {name=p3 lab=Vbp
}
C {devices/opin.sym} 50 -10 0 0 {name=p4 lab=Vbn
}
C {devices/opin.sym} 50 10 0 0 {name=p5 lab=Vcp
}
C {devices/opin.sym} 50 30 0 0 {name=p6 lab=Vcn

}
